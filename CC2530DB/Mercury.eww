<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Mercury.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>ALL</name>
            <member>
                <project>Mercury</project>
                <configuration>Mercury_EndDevice</configuration>
            </member>
            <member>
                <project>Mercury</project>
                <configuration>Mercury_Router</configuration>
            </member>
            <member>
                <project>Mercury</project>
                <configuration>Mercury_Router_CC2592</configuration>
            </member>
            <member>
                <project>Mercury</project>
                <configuration>Mercury_EndDevice_CC2592</configuration>
            </member>
            <member>
                <project>Mercury</project>
                <configuration>Mercury_EndDevice_CC2591</configuration>
            </member>
            <member>
                <project>Mercury</project>
                <configuration>Mercury_Router_CC2591</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
